# Keil uVision project tmr-fc.uvproj, settings and files
target TMR-FC (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: tmr-fc +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\platform\sys\inc;..\..\..\platform\src\inc;..\..\..\platform\inc;..\..\..\utilities\freertos\Source\portable\RVDS\ARM_CM4F;..\..\..\utilities\umpl\platform\include\linux;..\..\..\utilities\freertos\Source\include;..\..\..\utilities\umpl\platform\include;..\..\..\utilities\umpl\lite;..\..\..\utilities\fatfs\inc;..\..\..\platform\csp\STM32F4xx_DSP_StdPeriph_Lib_V1.0.1\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\platform\csp\STM32F4xx_DSP_StdPeriph_Lib_V1.0.1\Libraries\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../../../platform/sys/: startup_stm32f4xx.s system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../../platform/csp/STM32F4xx_DSP_StdPeriph_Lib_V1.0.1/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_wwdg.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c misc.c
  group FreeRTOS
    ../../../utilities/freertos/Source/: timers.c croutine.c list.c queue.c tasks.c
    ../../../utilities/freertos/Source/portable/MemMang/: heap_2.c
    ../../../utilities/freertos/Source/portable/RVDS/ARM_CM4F/: port.c
  group FatFs
    ../../../utilities/fatfs/src/: ff.c
    ../../../utilities/fatfs/port/: fattime.c diskio.c
  group apps
    ../../../platform/src/apps/: main.c
  group sys
    ../../../platform/sys/: stm32f4xx_it.c tmr_board.c
  group drivers
    ../../../platform/src/drivers/: drv_i2c.c drv_system.c drv_sdio_sd.c
  group umpl
    ../../../utilities/umpl/: umpl-states.c umpl-setup.c
    ../../../utilities/umpl/lite/: mlBiasNoMotion.c ml.c mlstates.c temp_comp_u.c ustore_manager.c mlarray_lite.c mldl.c mldl_cfg.c compass.c mlFIFO.c mlFIFOHW.c mlMathFunc.c mlsupervisor.c pressure.c accel.c mlcontrol.c mlSetGyroBias.c ml_invobj.c ustore_lite_fusion_delegate.c mldmp.c key0_96.c ml_init.c dmpDefaultMantis.c ustore_nvram_stm32_io.c mldl_cfg_init_umpl_6050a2.c
    ../../../utilities/umpl/lite/accel/: mpu6050.c
    ../../../utilities/umpl/platform/stm32/: mlsl_stm32.c mlos_stm32.c
