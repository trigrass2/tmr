# Keil uVision project tmr-fc.uvproj, settings and files
target TMR-FC (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: tmr-fc
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\platform\csp\st\STM32F4xx_StdPeriph_Driver\inc;..\..\platform\sys\inc;..\..\utilities\freertos\Source\include;..\..\utilities\freertos\Source\portable\stm32f4\inc;..\..\utilities\fatfs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../../platform/csp/arm/Device/STM32F4/Source/: startup_stm32f4xx.s system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../platform/csp/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS
    ../../utilities/freertos/Source/: timers.c croutine.c list.c queue.c tasks.c
    ../../utilities/freertos/Source/portable/MemMang/: heap_2.c
    ../../utilities/freertos/Source/portable/stm32f4/: port.c
  group FatFs
    ../../utilities/fatfs/src/: ff.c
    ../../utilities/fatfs/port/: fattime.c diskio.c
  group apps
    ../../platform/src/apps/: main.c
  group sys
    ../../platform/sys/: stm32f4xx_it.c
